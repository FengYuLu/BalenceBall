# Keil uVision project OV7670.uvprojx, settings and files
target LCD (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\OV7670;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\TIMER;..\HARDWARE\PICTURE_PROCESS;..\HARDWARE\ordinary_square_method;E:\module\Algorithm\FIGURE\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/OV7670/: ov7670.c sccb.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PICTURE_PROCESS/: PIC_process.c
    ../HARDWARE/ordinary_square_method/: olsm.c
    E:/module/Algorithm/FIGURE/sorce/: Figure.c Figure_Define.c Figure_Math.c Figure_Transform.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_tim.c
  group README
    ../: readme.txt
